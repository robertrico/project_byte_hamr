* b8fw.S - b8008_hamr SLOT ROM (MRLN32)
* PR#n -> 8008 GLASS TERMINAL.
* ENTRY RESTORES CSW=COUT1 (ELSE OUR
* COUT CALLS RE-ENTER THE ROM), PRINTS
* BANNER, THEN RUNS TTY ON THE FIFOS.
* WHOLE TERMINAL FITS THE 256-BYTE ROM:
* NO $C800, NO ARM/DISARM, NO SEI.
* ^Q RTSES TO BASIC OVER PR#'S JSR
* RETURN (OBSCURUS SLOT_ROM.S PATTERN).
* ^R REBOOTS THE 8008.
* NO OS NEEDED: PR#n WORKS FROM THE
* MONITOR PROMPT TOO; EXIT VIA CTRL-
* RESET IF THERE IS NOTHING TO RTS TO.
* SLOT EQUATE SETS ORG AND REG BASE.
* MAKEFILE OVERRIDES IT: make SLOT=n.
* CODE IS NOT POSITION INDEPENDENT -
* REASSEMBLE PER SLOT.
 TYP $06
 DSK b8fw.bin
SLOT = 4
 ORG SLOT*256+$C000

CSWL = $36
CSWH = $37
COUT1 = $FDF0
COUT = $FDED
KBD = $C000
KBDSTRB = $C010
B8BASE = SLOT*16+$C080
TXST = B8BASE+0
TXDAT = B8BASE+1
RXST = B8BASE+2
CTL = B8BASE+5

ENTRY LDA #<COUT1
 STA CSWL
 LDA #>COUT1
 STA CSWH
 LDA #$8D
 JSR COUT
 LDX #0
:b LDA BANNER,X
 BEQ LOOP
 JSR COUT
 INX
 BNE :b

* GLASS TTY: KBD->RX FIFO, TX FIFO->COUT
LOOP LDA KBD
 BPL :notx
 STA KBDSTRB
 CMP #$91 ; CTRL-Q = EXIT
 BEQ QUIT
 CMP #$92 ; CTRL-R = 8008 REBOOT
 BEQ RBOOT
 AND #$7F
 TAY
:w LDA RXST ; WAIT FIFO SPACE (BIT7)
 BPL :w
 TYA
 STA RXST
:notx LDA TXST ; BIT7 = BYTE AVAILABLE
 BPL LOOP
 LDA TXDAT
 CMP #$0A ; DROP LF (COUT CR DOES BOTH)
 BEQ LOOP
 ORA #$80
 JSR COUT
 JMP LOOP

RBOOT LDA #$52 ; 'R' HOLD RESET
 STA CTL
 LDA #$47 ; 'G' RELEASE - FULL BOOT
 STA CTL
 JMP LOOP

QUIT LDA #$8D
 JSR COUT
 RTS ; BACK TO BASIC OVER PR#'S JSR

BANNER ASC "B8008 TERM ^Q=EXIT ^R=RESET"
 DFB $8D,0
