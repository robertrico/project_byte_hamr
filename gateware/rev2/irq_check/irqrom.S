* irqrom.S - irq_check SLOT ROM
* PR#n RUNS IRQ THEN NMI TEST ON THIS
* CARD, PRINTS COUNTERS + PASS/FAIL.
* SAME ROM IN ANY SLOT: STUB FINDS ITS
* SLOT VIA IORTS, COPIES ROM TO $1000,
* JMPS THERE. ALL CODE AFTER THE STUB
* RUNS FROM RAM, SO ABS ADDRS WORK.
* ROM IS 2 PAGES: +8 SELECTS THE PAGE
* SEEN AT $Cn00. PAGE 1 IS COPIED FROM
* RAM CODE, THEN +8 BACK TO 0.
* OTHER irq_check CARD (OPPONENT) IS
* FOUND BY ROM SIGNATURE. PASS 1:
* OPP CLEARED (IDLE), O= IS ITS +5.
* PASS 2 (+): OPP RUNS TOO, BOTH PULL
* LOW TOGETHER, O= IS ITS TAKEN.
* RTS BACK OVER PR#'S COUT CALL.
 TYP $06
 DSK irqrom.bin
 ORG $1000

COUT = $FDED
PRBYTE = $FDDA
PRHEX = $FDE3
CROUT = $FD8E
SETVID = $FE93
IORTS = $FF58
PTRL = $06
PTRH = $07
P2L = $08
P2H = $09
SLOT16 = $EB
OPP16 = $EC
MODE = $ED
DUAL = $EE
OREG = $EF

* PIC STUB: NO ABS REFS INTO ROM
ENTRY SEI
 JSR SETVID
 JSR IORTS
 TSX
 LDA $0100,X
 STA PTRH
 LDY #0
 STY PTRL
COPY LDA (PTRL),Y
 STA $1000,Y
 INY
 BNE COPY
 JMP MAIN
SIG ASC "IRQK"

MAIN LDA PTRH
 ASL
 ASL
 ASL
 ASL
 STA SLOT16
 TAX
 LDA #1
 STA $C088,X
COP2 LDA (PTRL),Y
 STA $1100,Y
 INY
 BNE COP2
 TYA
 STA $C088,X
* RAM HANDLERS: IRQ LDA $45/RTI
 LDA #$A5
 STA $0300
 LDA #$45
 STA $0301
 LDA #$40
 STA $0302
 STA $03FB
 LDA #$00
 STA $03FE
 LDA #$03
 STA $03FF
* BANNER
 JSR CROUT
 LDY #T_BAN-TXT
 JSR PRS
 LDA PTRH
 JSR PRHEX
* FIND OPPONENT, SLOTS 7..1
 LDA #0
 STA OPP16
 STA P2L
 LDX #7
SCAN TXA
 ORA #$C0
 STA P2H
 CMP PTRH
 BEQ SNXT
 LDY #SIG-ENTRY+3
SCMP LDA (P2L),Y
 CMP (PTRL),Y
 BNE SNXT
 DEY
 CPY #SIG-ENTRY-1
 BNE SCMP
 LDY #T_OPP-TXT
 JSR PRS
 TXA
 JSR PRHEX
 TXA
 ASL
 ASL
 ASL
 ASL
 STA OPP16
 JMP RUN
SNXT DEX
 BNE SCAN
 LDY #T_NON-TXT
 JSR PRS
RUN LDA #0
 STA DUAL
 LDA #5
 STA OREG
 JSR PAIR
 LDA OPP16
 BEQ RDN
 STA DUAL
 LDA #1
 STA OREG
 JSR PAIR
RDN JSR CROUT
 RTS

PAIR LDA #1
 JSR TEST
 LDA #2
 JMP TEST

* A=1 IRQ, A=2 NMI. OPP GETS 0 OR,
* IF DUAL, THE SAME COMMAND FIRST
TEST STA MODE
 LDX OPP16
 BEQ TGO
 LDA DUAL
 BEQ TCL
 LDA MODE
TCL STA $C080,X
TGO LDX SLOT16
 LDA MODE
 STA $C080,X
 CMP #1
 BNE TWT
 CLI
TWT LDA $C080,X
 BPL TWT
 SEI
 JSR CROUT
 LDY #T_IRQ-TXT
 LDA MODE
 CMP #1
 BEQ TLB
 LDY #T_NMI-TXT
TLB JSR PRS
 LDA DUAL
 BEQ TL2
 LDA #$AB
 JSR COUT
TL2 LDY #T_LIN-TXT
* LINE: CHARS, 1-5 = OWN REG, 8 = OPP
LP LDA TXT,Y
 BEQ LEND
 BMI LCH
 CMP #8
 BEQ LOP
 ORA SLOT16
 TAX
 LDA $C080,X
 JSR PRBYTE
 JMP LNX
LOP LDA OPP16
 BEQ LNX
 ORA OREG
 TAX
 LDA $C080,X
 JSR PRBYTE
 JMP LNX
LCH JSR COUT
LNX INY
 BNE LP
* PASS = TAKEN $64 AND MISSED 0
LEND LDX SLOT16
 LDY #T_FAL-TXT
 LDA $C081,X
 CMP #$64
 BNE VPR
 LDA $C082,X
 BNE VPR
 LDY #T_PAS-TXT
VPR JMP PRS

* PRINT TXT+Y UNTIL 0
PRS LDA TXT,Y
 BEQ PRX
 JSR COUT
 INY
 BNE PRS
PRX RTS

TXT
T_BAN ASC "IRQ_CHECK SLOT "
 DFB 0
T_OPP ASC " OPP "
 DFB 0
T_NON ASC " OPP NONE"
 DFB 0
T_IRQ ASC "IRQ"
 DFB 0
T_NMI ASC "NMI"
 DFB 0
T_LIN ASC " T="
 DFB 1
 ASC " M="
 DFB 2
 ASC " L="
 DFB 3
 ASC "-"
 DFB 4
 ASC " S="
 DFB 5
 ASC " O="
 DFB 8,0
T_PAS ASC " PASS"
 DFB 0
T_FAL ASC " FAIL"
 DFB 0
