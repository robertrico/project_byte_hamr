* B8LIB.S - B8008 CARD DRIVER
* PUT-INCLUDE. NO ORG. NO ZERO PAGE.
* ABSOLUTE STA/LDA $C0Cx ONLY (NEVER ,X)
*
* ENTRY POINTS:
*  B8_PRESENT C=0 CARD OK  C=1 MISSING
*  B8_TXGET   C=0 A=BYTE   C=1 EMPTY
*  B8_RXPUT   A=BYTE C=0 SENT C=1 TIMEOUT
*  B8_RESET   HOLD 8008 IN RESET
*  B8_GO      RELEASE (REBOOT CEREMONY)
*  B8_TTY     GLASS TTY, CTRL-Q RETURNS
*  PRSTR      X=LO Y=HI OF ASCIIZ STRING

SLOT = 4
B8BASE = SLOT*16+$C080
B8TXST = B8BASE+0
B8TXDAT = B8BASE+1
B8RXST = B8BASE+2
B8CHKV = B8BASE+3
B8CHKC = B8BASE+4
B8STAT = B8BASE+5
B8PCLO = B8BASE+6
B8PCHI = B8BASE+7
B8LED = B8BASE+8
B8INT = B8BASE+9
B8ID = B8BASE+15

KBD = $C000
KBDSTRB = $C010
COUT = $FDED
PRBYTE = $FDDA
CROUT = $FD8E

B8VAL DS 1

* CARD PRESENT: ID REG READS $B8
B8_PRESENT
 LDA B8ID
 CMP #$B8
 BEQ :ok
 SEC
 RTS
:ok CLC
 RTS

* TX FIFO: C=0 A=BYTE, C=1 EMPTY
B8_TXGET
 LDA B8TXST
 BMI :has
 SEC
 RTS
:has LDA B8TXDAT
 CLC
 RTS

* RX FIFO PUSH, WAITS FOR SPACE (BOUNDED).
* PRESERVES X/Y (CALLERS LOOP ON THEM).
B8_RXPUT
 STA B8VAL
 TXA
 PHA
 TYA
 PHA
 LDX #0
 LDY #0
:w LDA B8RXST
 BMI :ok
 INY
 BNE :w
 INX
 BNE :w
 PLA
 TAY
 PLA
 TAX
 SEC
 RTS
:ok LDA B8VAL
 STA B8RXST
 PLA
 TAY
 PLA
 TAX
 LDA B8VAL
 CLC
 RTS

* 8008 RESET CONTROL
B8_RESET
 LDA #$52
 STA B8STAT
 RTS

B8_GO
 LDA #$47
 STA B8STAT
 RTS

* GLASS TTY. CTRL-Q QUITS. LF FILTERED
* (MONITOR SENDS CR+LF, COUT CR = BOTH)
B8_TTY
:lp LDA KBD
 BPL :nokey
 STA KBDSTRB
 CMP #$91
 BEQ :quit
 AND #$7F
 JSR B8_RXPUT
:nokey JSR B8_TXGET
 BCS :lp
 CMP #$0A
 BEQ :lp
 ORA #$80
 JSR COUT
 JMP :lp
:quit RTS

* PRINT ASCIIZ AT Y:X (SELF-MOD, NO ZP)
PRSTR
 STX :ld+1
 STY :ld+2
:ld LDA $FFFF
 BEQ :done
 JSR COUT
 INC :ld+1
 BNE :ld
 INC :ld+2
 BNE :ld
:done RTS
