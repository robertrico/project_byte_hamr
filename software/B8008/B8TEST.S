* B8TEST.S - B8008 CARD SMOKE TEST
* BRUN B8TEST: CHECKS ID, PRINTS CPU
* STATUS + CHECKPOINTS + PC, THEN DRAINS
* THE TX FIFO (= THE MONITOR BOOT BANNER)
 TYP $06
 DSK B8TEST
 ORG $2000
 JMP MAIN
 PUT B8LIB

MAIN JSR CROUT
 JSR B8_PRESENT
 BCC :ok
 LDX #<MSGNO
 LDY #>MSGNO
 JSR PRSTR
 RTS
:ok LDX #<MSGOK
 LDY #>MSGOK
 JSR PRSTR

 LDX #<MSGST
 LDY #>MSGST
 JSR PRSTR
 LDA B8STAT
 JSR PRBYTE

 LDX #<MSGPC
 LDY #>MSGPC
 JSR PRSTR
 LDA B8PCHI
 JSR PRBYTE
 LDA B8PCLO
 JSR PRBYTE

 LDX #<MSGCK
 LDY #>MSGCK
 JSR PRSTR
 LDA B8CHKV
 JSR PRBYTE
 LDA #$AF
 JSR COUT
 LDA B8CHKC
 JSR PRBYTE
 JSR CROUT

* DRAIN TX FIFO = SHOW BOOT BANNER
 LDX #<MSGTX
 LDY #>MSGTX
 JSR PRSTR
:drain JSR B8_TXGET
 BCS :done
 CMP #$0A
 BEQ :drain
 ORA #$80
 JSR COUT
 JMP :drain
:done JSR CROUT
 LDX #<MSGDN
 LDY #>MSGDN
 JSR PRSTR
 RTS

MSGNO ASC "NO B8008 CARD IN SLOT 4"
 DFB $8D,0
MSGOK ASC "B8008 CARD OK (ID $B8)"
 DFB $8D,0
MSGST ASC "CPU STAT=$"
 DFB 0
MSGPC ASC " PC=$"
 DFB 0
MSGCK ASC " CHKPT=$"
 DFB 0
MSGTX ASC "TX FIFO:"
 DFB $8D,0
MSGDN ASC "B8TEST DONE"
 DFB $8D,0
