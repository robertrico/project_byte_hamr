* B8TERM.S - GLASS TTY TO THE 8008 MONITOR
* BRUN B8TERM. KEYS GO TO THE 8008 (IN 1),
* 8008 OUT 9 PRINTS HERE. CTRL-Q QUITS.
* MONITOR CMDS: H D W L G (SEE HANDBOOK)
 TYP $06
 DSK B8TERM
 ORG $2000
 JMP MAIN
 PUT B8LIB

MAIN JSR CROUT
 JSR B8_PRESENT
 BCC :ok
 LDX #<MSGNO
 LDY #>MSGNO
 JSR PRSTR
 RTS
:ok LDX #<MSGHI
 LDY #>MSGHI
 JSR PRSTR
 JSR B8_TTY
 JSR CROUT
 LDX #<MSGBY
 LDY #>MSGBY
 JSR PRSTR
 RTS

MSGNO ASC "NO B8008 CARD IN SLOT 4"
 DFB $8D,0
MSGHI ASC "B8TERM - CTRL-Q QUITS"
 DFB $8D,0
MSGBY ASC "B8TERM DONE"
 DFB $8D,0
