* SDRAMLIB.S - OBSCURUS SDRAM DRIVER
* PUT-INCLUDE. NO ORG. NO ZERO PAGE.
* ABSOLUTE STA/LDA $C0Cx ONLY (NEVER ,X)
*
* PARAMS:
*  SDM_BANK(2) SDM_ADDR(2) SDM_VAL(1)
* ENTRY POINTS:
*  SDM_READY  C=0 RDY  C=1 TIMEOUT
*  SDM_SETBANK  SDM_SETADDR
*  SDM_WRITE  SDM_READ
*  SDM_WRNEXT SDM_RDNEXT (AUTO-INC)
* NEXT NEEDS A PRIOR SETADDR/WRITE/READ
* CHANGE SLOT EQUATE FOR OTHER SLOTS

SLOT = 4
SDMBASE = SLOT*16+$C080
R_ADRLO = SDMBASE+0
R_ADRHI = SDMBASE+1
R_BNKLO = SDMBASE+2
R_BNKHI = SDMBASE+3
R_TRIG = SDMBASE+4
R_STAT = SDMBASE+5
R_DATA = SDMBASE+6
R_ARM = SDMBASE+7
R_DISARM = SDMBASE+8

SDM_BANK DS 2
SDM_ADDR DS 2
SDM_VAL DS 1

* READY: C=0 RDY  C=1 TIMEOUT
SDM_READY LDX #0
 LDY #0
:lp BIT R_STAT
 BVS :rdy
 INY
 BNE :lp
 INX
 BNE :lp
 SEC
 RTS
:rdy CLC
 RTS

SDM_SETBANK
 LDA SDM_BANK
 STA R_BNKLO
 LDA SDM_BANK+1
 STA R_BNKHI
 RTS

SDM_SETADDR
 LDA SDM_ADDR
 STA R_ADRLO
 LDA SDM_ADDR+1
 STA R_ADRHI
 RTS

* WAIT BUSY CLEAR (BIT7)
SDM_POLL LDA R_STAT
 BMI SDM_POLL
 RTS

SDM_WRITE JSR SDM_SETBANK
 JSR SDM_SETADDR
 LDA SDM_VAL
 STA R_DATA
 JMP SDM_POLL

SDM_READ JSR SDM_SETBANK
 JSR SDM_SETADDR
 STA R_TRIG
 JSR SDM_POLL
 LDA R_DATA
 STA SDM_VAL
 RTS

SDM_WRNEXT
 LDA SDM_VAL
 STA R_DATA
 JMP SDM_POLL

SDM_RDNEXT
 STA R_TRIG
 JSR SDM_POLL
 LDA R_DATA
 STA SDM_VAL
 RTS

* $C800 ROM ARM/DISARM (NOT FOR SDRAM)
SDM_ROMON LDA #$AA
 STA R_ARM
 RTS
SDM_ROMOFF
 LDA #$AA
 STA R_DISARM
 RTS
